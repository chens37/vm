## linux-stable/drivers/globalmem/Kconfig
```kconfig
#
# I2C subsystem configuration
#


config GLOBALMEM
	tristate "globalmem support"
	---help---
		globalmem	  
```
